Commit message: update k-means

File: model/plane/dynamic.urdf (robot description, URDF)
Before this commit: robot thine_plane, 1 links, 0 joints
Links:
- link baseLink: geometry visual mesh filename=cube.obj scale=0.05 0.15 0.05
